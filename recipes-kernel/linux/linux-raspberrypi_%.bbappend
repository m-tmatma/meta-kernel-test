FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
file://defconfig \
"

SRC_URI[md5sum] = "0fa99178785da34deab97090ec92b910"
SRC_URI[sha256sum] = "e023298e1a6a60f667bf4744bb2cb405073bb723e343854aede418155da91725"
